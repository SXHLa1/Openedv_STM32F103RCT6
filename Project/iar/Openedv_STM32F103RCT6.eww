<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Openedv_STM32F103RCT6.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>Openedv_STM32F103RCT6</name>
            <member>
                <project>Openedv_STM32F103RCT6</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
